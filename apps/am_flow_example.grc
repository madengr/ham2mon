options:
  parameters:
    category: Custom
    description: Example of GR DSP flow in receiver.py
    generate_options: qt_gui
    id: am_flow_example
    output_language: python
    title: Ham2Mon AM Receiver Flow Example
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 144E6
  states: {}
- name: demod_bb_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,3
    label: '"Demod BB Freq (Hz)"'
    outputmsgname: value
    showports: 'False'
    start: '-samp_rate/2'
    step: 5E3
    stop: samp_rate/2
    value: 390E3
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: 256 * int(pow(2, np.ceil(np.log(samp_ratio)/np.log(2))))
  states: {}
- name: file_name
  id: variable
  parameters:
    value: '"test.wav"'
  states: {}
- name: final_decim
  id: variable
  parameters:
    value: int(samp_rate/1E6)
  states: {}
- name: final_rate
  id: variable
  parameters:
    value: samp_rate/initial_decim**2/int(samp_rate/1E6)
  states: {}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,3
    label: '"HW Gain (dB)"'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: initial_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 1E6 minimum
    value: 1E6
  states: {}
- name: samp_ratio
  id: variable
  parameters:
    value: samp_rate/1E6
  states: {}
- name: squelch_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,3
    label: '"Squelch (dB)"'
    outputmsgname: value
    showports: 'False'
    start: '-100'
    step: '5'
    stop: '0'
    value: '-70'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '0.090'
    gain: '1.0'
    samp_rate: '1'
    width: '0.010'
    win: window.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 12.5E3
    gain: '1.0'
    samp_rate: samp_rate/25
    width: 1E3
    win: window.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_2
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3500'
    gain: '1.0'
    samp_rate: final_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-0'
    decay_rate: '1e-4'
    gain: '10'
    iir_update_decim: '1'
    max_gain: '10000'
    reference: '0.1'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.1'
    gate: 'False'
    ramp: '0'
    threshold: squelch_dB
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.1'
    gate: 'True'
    ramp: '0'
    threshold: '-200'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Compute power
    vlen: fft_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: Video average down to 10 FFT/sec
    decim: '100'
    type: float
    vlen: fft_length
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Want about 1000 FFT/sec
      Keep 1 in 4 vectors
    n: int(round(samp_rate/fft_length/1000))
    type: complex
    vlen: fft_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_length
  states: {}
- name: blocks_probe_signal_vx_0
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: fft_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Example:
      1024 length FFT
      4 Msps / 1024 = 3906.25 Hz/bin
      Also 3902.25 vec/sec
    num_items: fft_length
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_length
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: file_name
    format: FORMAT_WAV
    samp_rate: '16000'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: samp_rate/5 to samp_rate/25
    decim: initial_decim
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    comment: samp_rate/100 to 40-80 ksps
    decim: int(samp_rate/1E6)
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    comment: 40-80 ksps to 8-16 ksps
    decim: initial_decim
    taps: variable_low_pass_filter_taps_0
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: demod_bb_freq
    comment: samp_rate to samp_rate/5
    decim: initial_decim
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: uhd
    bb_gain0: '20'
    bw0: samp_rate*0.8
    freq0: center_freq
    gain0: gain_db
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Note this is set for 16 kHz (not 8 kHz)
    nfilts: '32'
    rrate: 16E3/float(final_rate/5)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 144E6
    fftsize: fft_length
    gui_hint: 0,0,3,1
    name: '"Spectrum"'
    showports: 'True'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: final_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,3,1
    name: '"Decimated Channel"'
    showports: 'True'
    type: complex
    ymax: '-60'
    ymin: '-200'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,3,1
    label1: ''
    name: '"Averaged Spectrum"'
    size: fft_length
    srate: samp_rate
    type: float
    ylabel: Power
    ymax: '40'
    ymin: '-60'
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_agc3_xx_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_mag_0, '0', fir_filter_xxx_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_probe_signal_vx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0, '0', fir_filter_xxx_0_0, '0']
- [fir_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_0_1, '0', pfb_arb_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
