<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_flow_example</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Example of GR DSP flow in receiver.py</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Ham2Mon AM Receiver Flow Example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>144E6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>demod_bb_freq</value></param>
<param><key>value</key><value>390E3</value></param>
<param><key>gui_hint</key><value>3,1,1,3</value></param>
<param><key>label</key><value>"Demod BB Freq (Hz)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>5E3</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>256 * int(pow(2, np.ceil(np.log(samp_ratio)/np.log(2))))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name</value></param>
<param><key>value</key><value>"test.wav"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_decim</value></param>
<param><key>value</key><value>int(samp_rate/1E6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_rate</value></param>
<param><key>value</key><value>samp_rate/initial_decim**2/int(samp_rate/1E6)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_db</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>4,1,1,3</value></param>
<param><key>label</key><value>"HW Gain (dB)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>1E6 minimum</value></param>
<param><key>value</key><value>1E6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_ratio</value></param>
<param><key>value</key><value>samp_rate/1E6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch_dB</value></param>
<param><key>value</key><value>-70</value></param>
<param><key>gui_hint</key><value>5,1,1,3</value></param>
<param><key>label</key><value>"Squelch (dB)"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>variable_low_pass_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>0.090</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>width</key><value>0.010</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>variable_low_pass_filter_taps_1</value></param>
<param><key>cutoff_freq</key><value>12.5E3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate/25</value></param>
<param><key>width</key><value>1E3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>variable_low_pass_filter_taps_2</value></param>
<param><key>cutoff_freq</key><value>3500</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>final_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>attack_rate</key><value>1e-0</value></param>
<param><key>decay_rate</key><value>1e-4</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>iir_update_decim</key><value>1</value></param>
<param><key>max_gain</key><value>10000</value></param>
<param><key>reference</key><value>0.1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>squelch_dB</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-200</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>16000</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>comment</key><value>Compute power</value></param>
<param><key>vlen</key><value>fft_length</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>comment</key><value>Video average down to 10 FFT/sec</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_length</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>comment</key><value>Want about 1000 FFT/sec
Keep 1 in 4 vectors</value></param>
<param><key>n</key><value>int(round(samp_rate/fft_length/1000))</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_length</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>fft_length</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>comment</key><value>Example:
1024 length FFT
4 Msps / 1024 = 3906.25 Hz/bin
Also 3902.25 vec/sec</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_length</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_length</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>file_name</value></param>
<param><key>samp_rate</key><value>16000</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_length)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>comment</key><value>samp_rate/5 to samp_rate/25</value></param>
<param><key>decim</key><value>initial_decim</value></param>
<param><key>taps</key><value>variable_low_pass_filter_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>comment</key><value>samp_rate/100 to 40-80 ksps</value></param>
<param><key>decim</key><value>int(samp_rate/1E6)</value></param>
<param><key>taps</key><value>variable_low_pass_filter_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_1</value></param>
<param><key>comment</key><value>40-80 ksps to 8-16 ksps</value></param>
<param><key>decim</key><value>initial_decim</value></param>
<param><key>taps</key><value>variable_low_pass_filter_taps_0</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>demod_bb_freq</value></param>
<param><key>comment</key><value>samp_rate to samp_rate/5</value></param>
<param><key>decim</key><value>initial_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>variable_low_pass_filter_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate*0.8</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain_db</value></param>
<param><key>args</key><value>uhd</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>comment</key><value>Note this is set for 16 kHz (not 8 kHz)</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>16E3/float(final_rate/5)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>144E6</value></param>
<param><key>fftsize</key><value>fft_length</value></param>
<param><key>gui_hint</key><value>0,0,3,1</value></param>
<param><key>name</key><value>"Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>final_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,3,1</value></param>
<param><key>name</key><value>"Decimated Channel"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-60</value></param>
<param><key>ymin</key><value>-200</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,1,3,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Averaged Spectrum"</value></param>
<param><key>size</key><value>fft_length</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Power</value></param>
<param><key>ymax</key><value>40</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
